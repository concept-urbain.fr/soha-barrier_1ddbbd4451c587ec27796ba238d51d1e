Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Soha Barrière.IFC
Time: 2020-07-03T09:50:10
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: MULT-LIS-001_1000
In: Default Storey
Material: Alliage 1060

# IfcBuildingElementProxy: SOHA-BAR-100-002-01_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 20.345; Area Measure: 0.638775; Volume Measure: 0.00296815
